# Keil uVision project project_3.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: project_3
  c flags: Optim=1
  c define: __RTGT_UART
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x2007c000 size 0x160000
  group Source Group 1
    ./: startup_LPC17xx.s array_tools.c main.c quicksort.c Retarget.c RTX_Conf_CM.c system_LPC17xx.c uart.c Serial.c
