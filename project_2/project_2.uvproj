# Keil uVision project project_2.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: project_2
  c flags: Optim=4 oTime=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x4000
  group Source Group 1
    ./: startup_LPC17xx.s half_fit_test.c half_fit.c half_fit.h type.h util.h uart.h uart.c Retarget.c
    C:/Keil/ARM/Startup/NXP/LPC17xx/: system_LPC17xx.c
